DEPENDS += "cjson"
LDFLAGS += "-lcjson"
