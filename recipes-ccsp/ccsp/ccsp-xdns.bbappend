DEPENDS_remove = "webconfig-framework"
